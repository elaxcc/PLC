# Keil uVision project PLC.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: PLC
  c flags: Optim=1
  c define: STM32F10X_HD YDEBUG
  c include: .\Headers;.\YLibrary
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup
    ./: startup_stm32f10x_hd.s
    ./Sources/: system_stm32f10x.c
  group Main
    ./Sources/: main.c plc.c
  group YLibrary
    ./YLibrary/: YDebug.c YDelay.c
